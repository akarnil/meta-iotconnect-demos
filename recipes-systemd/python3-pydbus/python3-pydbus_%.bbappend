FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append = "file://0001-Adding-option-to-create-dbus-object-from-.xml_conten.patch"